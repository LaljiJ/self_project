# Keil uVision project Automated_Safty_Syestem_For_Automobile.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: p +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: header.h delay.c io_driver.c lcd_driver.c uart_driver.c adc_driver_POT.c adc_driver_LDR.c main.c pwm_driver.c ultra_driver.c
